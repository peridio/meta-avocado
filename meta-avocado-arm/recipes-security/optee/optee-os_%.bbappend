# EXTRA_OEMAKE:append:qemuarm64-secureboot = "CFG_CORE_HEAP_SIZE=131072 CFG_TEE_BENCHMARK=n CFG_TEE_CORE_LOG_LEVEL=4"
EXTRA_OEMAKE:append = "CFG_TEE_CORE_LOG_LEVEL=4 CFG_TEE_TA_LOG_LEVEL=4 CFG_CORE_ASLR=n"
EXTRA_OEMAKE:append = "CFG_IN_TREE_EARLY_TAS+=pkcs11/fd02c9da-306c-48c7-a49c-bbd827ae86ee"
EXTRA_OEMAKE:append = "CFG_IN_TREE_EARLY_TAS+=trusted_keys/f04a0fe7-1f5d-4b9b-abf7-619b85b4ce8c"
EXTRA_OEMAKE:append = "CFG_IN_TREE_EARLY_TAS+=fTPM/bc50d971-d4c9-42c4-82cb-343fb7f37896"
