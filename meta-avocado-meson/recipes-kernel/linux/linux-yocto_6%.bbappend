FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
  file://drm-panel.cfg \
"