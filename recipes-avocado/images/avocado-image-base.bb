DESCRIPTION = "Avocado base image"

require avocado-image-common.inc
