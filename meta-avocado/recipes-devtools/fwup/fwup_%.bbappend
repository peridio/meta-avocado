FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Increase-GPT_MAX_PARTITIONS-to-32.patch"

