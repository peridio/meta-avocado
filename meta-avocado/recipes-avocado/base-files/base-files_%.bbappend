do_install:append() {
    install -d ${D}/data
}
